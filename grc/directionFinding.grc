options:
  parameters:
    generate_options: qt_gui
    id: directionFinding
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: d
  id: variable
  parameters:
    value: '.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: vector_size
  id: variable
  parameters:
    value: '180'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, input_count=3, sample_rate=35e6, vector_size=180):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.complex64, vector_size) for i in range(input_count)],
                  out_sig=[(np.float32, vector_size)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sample_rate = sample_rate
              self.vector_size = vector_size
              self.input_count = input_count


          def work(self, input_items, output_items):
              """Calculate a angle using capon beam former"""
              angles = np.linspace(0, 2, self.vector_size) * np.pi
              for i in range(np.asarray(input_items).shape[1]):
                  sig = np.squeeze(np.matrix(np.asanyarray(input_items)[:, i, :]))
                  power = []
                  for theta in angles:
                      # The weight vector simmilar in form to a beamformer generating signal
                      a = np.matrix(np.exp(2*-1j*np.pi*np.arange(self.input_count)*np.sin(theta)))
                      # Multiply the wegits with the signal then average result
                      r = sig @ sig.H
                      print(r.shape)
                      r = np.linalg.inv(r)
                      power.append(np.mean(20*np.log10(np.abs(1/(np.conj(a) @ r @ a.T)))))
                  output_items[0][i] = power
              return len(output_items[0])
    input_count: '3'
    sample_rate: samp_rate
    vector_size: vector_size
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: vector_size
    x_start: '360'
    x_step: '-2'
    ymin: '-10'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:60000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:60001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_1
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:60002
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0, '1']
- [blocks_stream_to_vector_0_1, '0', epy_block_0, '2']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle2_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_throttle2_0_1, '0', qtgui_time_sink_x_0, '2']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle2_0, '0']
- [zeromq_sub_source_0_0, '0', blocks_throttle2_0_0, '0']
- [zeromq_sub_source_0_1, '0', blocks_throttle2_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
